# Repository akfrnswrth/AIA-Schematics

File README.md:

AIA-Schematics
==============

Schematics for the Analog Integrated Amplifier Rev. B

## KiCad design power amp/AIA power amp.kicad_pcb

Parts:
C1: 33u
C2: 100p
C3, C4, C5: 100n
J1: AMP POWER
J2: AMP IN
J3: AMP OUT
R1: 47k
R2, R4: 1k
R3: 10
R5: 10k
U1: LM1875; TO220-5

Connections:
GND: C1.2, C3.2, C4.1, C5.2, J1.2, J1.3, J1.4, J2.1, J3.2 (PM), R1.2
unnamed: C5.1, R3.2
unnamed: R2.2, U1.1 (IN+)
unnamed: J2.2 (PM), R1.1, R2.1
unnamed: C2.2, J3.1, R3.1, R5.2, U1.4 (OUT)
unnamed: C1.1, R4.1
unnamed: C2.1, R4.2, R5.1, U1.2 (IN-)
VCC: C3.1, J1.1, U1.5 (VCC)
VEE: C4.2, J1.5, U1.3 (VEE)

Board: 2 copper layers, 27.3 x 39.4 mm, 18 parts (0 on the bottom side), 9 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## KiCad design power supply/AIA power supply.kicad_pcb

Parts:
C5, C6, C8: 0.1 uF
C7: 470 pF
C9: 470 uF
C10: 100 uF
D2: 1N5819
J5: EXP POWER
J6, J7, J8, J9: HOLE
J101: PRE PWR
J102, J103: AMP PWR
J104: CB PWR
L1: 100 uH
L2: 1 uH
P1: 17V CAPS
R1, R2, R3, R4: 1
R5: 1.2k
R6, R101: 33k
U1: 7805
U2: MC34063

Connections:
AGND: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D2.1 (A), J5.2, J5.4, J5.6, J101.2, J101.4, J102.2, J102.3, J102.4, J103.2, J103.3, J103.4, J104.2, J104.4, P1.2 (PM), R5.2, U1.GND, U2.4 (GND)
unnamed: D2.2 (K), L1.1, U2.2 (Sw_Emit)
unnamed: C7.1, U2.3 (Tim_Cap)
unnamed: R5.1, R6.2, R101.2, U2.5 (V_Sense)
unnamed: C9.1, L1.2, L2.1, R6.1, R101.1
unnamed: R1.1, R2.1, R3.1, R4.1, U2.1 (Sw_Coll), U2.7 (I_Sense), U2.8 (Drv_Coll)
VAA: C6.1, J5.5, J101.3, J104.3, U1.VO
VCC: C5.1, C8.1, J5.1, J102.1, J103.1, P1.3, R1.2, R2.2, R3.2, R4.2, U1.VI, U2.6 (VCC)
VDD: C10.1, J5.3, J101.1, J104.1, L2.2
VEE: J5.7, J102.5, J103.5, P1.1

Board: 2 copper layers, 58.4 x 45.7 mm, 28 parts (0 on the bottom side), 10 nets.

## KiCad design control board/AIA control board.kicad_pcb

Parts:
C101, C102, C104, C105, C114, C123: 100n
C103: 100u
C106, C107, C108, C109, C110, C111, C112, C113, C115, C116, C117, C118, C119, C120, C121, C122: 470n
D101: EEPROM
IC101: ATMEGA168-A; TQFP32
J101: TSOP48
J102: LINE IN
J103: ENCODERS
J104: ICSP
J105: DISPLAY
J106: CB POWER
J107: AMP INR
J108: AMP OUTL
J109: AMP OUTR
J110: HP OUT/DET
JP101: ICSP POWER
K101: EC2-5NU
P102: AMP INL
Q101: 2N2222
R101: LDR
R102: 10k
R103, R104, R105, R106, R107, R108, R109, R110, R114, R115, R116, R117, R118, R119, R120, R121: 22k
R111, R112, R113, R128: 1k
R125, R126, R129, R130: 470
R127: 4.7k
R131: 330
SP101: SPK OUTL
SP102: SPK OUTR
U102, U103: MAX4617

Connections:
+5VA: C103.1, C104.1, C105.1, J106.3, U102.16 (VCC), U103.16 (VCC); also elsewhere on the board
+5VD: C101.1, C102.1, C123.1, J101.3, J105.1, J106.1, JP101.2, K101.1 (COIL_1), R101.2 (PM); also elsewhere on the board
/AIA Rev. B Control Board Preamp/PRE_INL: U102.3 (X); also elsewhere on the board
/AIA Rev. B Control Board Preamp/PRE_OUTL: P102.2 (PM); also elsewhere on the board
/AIA Rev. B Control Board Preamp/PRE_OUTR: J107.2 (PM); also elsewhere on the board
/AIA Rev. B Control Board Preamp/SPI_MOSI: J104.4, J105.5; also elsewhere on the board
/AIA Rev. B Control Board Preamp/SPI_SCK: J104.3, J105.4; also elsewhere on the board
/AVR_RESET: J104.5; also elsewhere on the board
/EE_LED: R131.1; also elsewhere on the board
/HP_DET: R128.2; also elsewhere on the board
/LIGHT_SENSE: R101.1, R102.1; also elsewhere on the board
/LINE_L0: C115.1, J102.2
/LINE_L1: C116.1, J102.5
/LINE_L2: C117.1, J102.8
/LINE_L3: C118.1, J102.11
/LINE_L4: C119.1, J102.14
/LINE_L5: C120.1, J102.17
/LINE_L6: C121.1, J102.20
/LINE_L7: C122.1, J102.24
/LINE_R0: C106.1, J102.3
/LINE_R1: C107.1, J102.6
/LINE_R2: C108.1, J102.9
/LINE_R3: C109.1, J102.12
/LINE_R4: C110.1, J102.15
/LINE_R5: C111.1, J102.18
/LINE_R6: C112.1, J102.21
/LINE_R7: C113.1, J102.23
/OP_SW: R127.2; also elsewhere on the board
/PINC_BACK: J103.7; also elsewhere on the board
/PINC_ENTER: J103.2; also elsewhere on the board
/PINC_LEFT: J103.9; also elsewhere on the board
/PINC_RIGHT: J103.10; also elsewhere on the board
/PINC_VOLDN: J103.5; also elsewhere on the board
/PINC_VOLUP: J103.4; also elsewhere on the board
/REM_RX: J101.1; also elsewhere on the board
/SEL_ADDR0: R112.1; also elsewhere on the board
/SEL_ADDR1: R113.1; also elsewhere on the board
/SEL_ADDR2: R111.1; also elsewhere on the board
/SPI_MISO: J104.1; also elsewhere on the board
/VFD_CS: J105.3; also elsewhere on the board
DGND: C101.2, C102.2, C114.2, C123.2, D101.2 (K), J101.2 (PM), J103.1, J103.3, J103.6, J103.8, J104.6, J105.2, J106.2, Q101.1 (E), R102.2; also elsewhere on the board
unnamed: J104.2, JP101.1
unnamed: R119.2, U102.5 (X5)
unnamed: R117.2, U102.12 (X3)
unnamed: R118.2, U102.1 (X4)
unnamed: R120.2, U102.2 (X6)
unnamed: R121.2, U102.4 (X7)
unnamed: R116.2, U102.15 (X2)
unnamed: J110.2, R125.1, R129.2
unnamed: J110.4, R128.1
unnamed: J109.1, K101.9 (C1), R126.2
unnamed: J108.1, K101.4 (C2), R125.2
unnamed: K101.8 (T1), SP102.2
unnamed: K101.5 (T2), SP101.2
unnamed: Q101.2 (B), R127.1
unnamed 70: C114.1; also elsewhere on the board
unnamed: K101.12 (COIL_2), Q101.3 (C)
unnamed: D101.1 (A), R131.2
unnamed: R111.2, U102.9 (C), U103.9 (C)
unnamed: R113.2, U102.10 (B), U103.10 (B)
unnamed: R112.2, U102.11 (A), U103.11 (A)
unnamed: J110.3, R126.1, R130.2
unnamed: J108.2 (PM), J109.2 (PM), J110.1, R129.1, R130.1, SP101.1, SP102.1
unnamed: R106.2, U103.12 (X3)
unnamed: R107.2, U103.1 (X4)
unnamed: R108.2, U103.5 (X5)
unnamed: C116.2, R115.1
unnamed: R115.2, U102.14 (X1)
unnamed: R114.2, U102.13 (X0)
unnamed: C115.2, R114.1
unnamed: C117.2, R116.1
unnamed: C118.2, R117.1
unnamed: C119.2, R118.1
unnamed: C120.2, R119.1
unnamed: C108.2, R105.1
unnamed: C109.2, R106.1
unnamed: C110.2, R107.1
unnamed: C111.2, R108.1
unnamed: C106.2, R103.1
unnamed: C121.2, R120.1
unnamed: C122.2, R121.1
unnamed: C112.2, R109.1
unnamed: C113.2, R110.1
unnamed: R104.2, U103.14 (X1)
unnamed: R109.2, U103.2 (X6)
unnamed: R110.2, U103.4 (X7)
unnamed: R105.2, U103.15 (X2)
unnamed: R103.2, U103.13 (X0)
unnamed: C107.2, R104.1

Schematic: preamp.sch, AIA Rev. B Control Board Preamp

Parts:
C201, C202, C203, C206, C207, C208: 10u
C204, C209: 47n
C205, C210: 1n
C211, C212, C213, C214, C215: 100n
R201, R204, R207, R209, R210, R213, R221, R224, R227, R230: 22k
R202, R219: 4.7k
R203, R220: 33k
R205, R222: 2.2k
R206, R223: 100k
R208, R211, R212, R214, R225, R228, R229, R231: 10k
R215, R216, R217: 1k
R218, R226: 47k
U201, U205: TL972
U202: MCP42100_VOL
U203: MCP42100_TREB
U204: MCP42100_BASS

Connections:
+5VA: C211.1, C212.1, C213.1, C214.1, C215.1, R201.1, R204.1, R218.1, R221.1, U201.8 (V+), U202.11 (~Reset), U202.12 (~SHDN), U202.14 (VCC), U203.11 (~Reset), U203.12 (~SHDN), U203.14 (VCC), U204.11 (~Reset), U204.12 (~SHDN), U204.14 (VCC), U205.8 (V+); also elsewhere on the board
/AIA Rev. B Control Board Preamp/BASS_PA0: C204.1, R207.2, U204.8 (PA0)
/AIA Rev. B Control Board Preamp/BASS_PB0: C204.2, R213.1, U204.10 (PB0)
/AIA Rev. B Control Board Preamp/BASS_PB1: C209.2, R230.1, U204.5 (PB1)
/AIA Rev. B Control Board Preamp/BASS_PW0: R212.1, U204.9 (PW0)
/AIA Rev. B Control Board Preamp/BASS_PW1: R229.1, U204.6 (PW1)
/AIA Rev. B Control Board Preamp/POT_CS: R215.1; also elsewhere on the board
/AIA Rev. B Control Board Preamp/PRE_INL: R203.1, U202.8 (PA0); also elsewhere on the board
/AIA Rev. B Control Board Preamp/PRE_OUTL: C201.2, R206.1; also elsewhere on the board
/AIA Rev. B Control Board Preamp/PRE_OUTR: C206.2, R223.1; also elsewhere on the board
/AIA Rev. B Control Board Preamp/SPI_MOSI: R217.1; also elsewhere on the board
/AIA Rev. B Control Board Preamp/SPI_SCK: R216.1; also elsewhere on the board
/AIA Rev. B Control Board Preamp/TREB_PA0: R208.2, U203.8 (PA0)
/AIA Rev. B Control Board Preamp/TREB_PB0: R214.1, U203.10 (PB0)
/AIA Rev. B Control Board Preamp/TREB_PB1: R231.1, U203.5 (PB1)
/AIA Rev. B Control Board Preamp/TREB_PW0: C205.2, U203.9 (PW0)
/AIA Rev. B Control Board Preamp/TREB_PW1: C210.2, U203.6 (PW1)
/AIA Rev. B Control Board Preamp/VOL_PB0: C203.1, R203.2, R204.2, R205.1, R210.1, U202.10 (PB0)
/AIA Rev. B Control Board Preamp/VOL_PB1: C208.1, R220.2, R221.2, R222.1, R227.1, U202.5 (PB1)
/AIA Rev. B Control Board Preamp/VOL_PW0: U201.5 (+), U202.9 (PW0)
/AIA Rev. B Control Board Preamp/VOL_PW1: U202.6 (PW1), U205.5 (+)
unnamed: R219.1, R230.2, R231.2, U205.1
unnamed: C210.1, R229.2, U205.2 (-)
unnamed: C207.1, R218.2, R226.1, U205.3 (+)
unnamed: R215.2, U202.1 (~CS), U203.1 (~CS), U204.1 (~CS)
unnamed: C206.1, R219.2
unnamed: R224.1, R225.1, R228.1, U205.7
unnamed: R222.2, R228.2, U205.6 (-)
unnamed: U203.3 (SI), U204.13 (SO)
unnamed: U202.13 (SO), U204.3 (SI)
unnamed: R216.2, U202.2 (SCK), U203.2 (SCK), U204.2 (SCK)
unnamed: R207.1, R208.1, R211.1, U201.7
unnamed: R217.2, U202.3 (SI)
unnamed: R205.2, R211.2, U201.6 (-)
unnamed: C201.1, R202.2
unnamed: R202.1, R213.2, R214.2, U201.1
unnamed: C205.1, R212.2, U201.2 (-)
unnamed: C202.1, R201.2, R209.1, U201.3 (+)

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
Board: 2 copper layers, 160.0 x 132.1 mm, 122 parts (0 on the bottom side), 125 nets.

Other parts of the board:
U101: ATMEGA168-P; DIP-28__300_ELL

Their connections:
+5VD: U101.7, U101.20; also elsewhere on the board
/AIA Rev. B Control Board Preamp/POT_CS: U101.16; also elsewhere on the board
/AIA Rev. B Control Board Preamp/SPI_MOSI: U101.17; also elsewhere on the board
/AIA Rev. B Control Board Preamp/SPI_SCK: U101.19; also elsewhere on the board
/AVR_RESET: U101.1; also elsewhere on the board
/EE_LED: U101.9; also elsewhere on the board
/HP_DET: U101.10; also elsewhere on the board
/LIGHT_SENSE: U101.28; also elsewhere on the board
/OP_SW: U101.26; also elsewhere on the board
/PINC_BACK: U101.5; also elsewhere on the board
/PINC_ENTER: U101.4; also elsewhere on the board
/PINC_LEFT: U101.12; also elsewhere on the board
/PINC_RIGHT: U101.13; also elsewhere on the board
/PINC_VOLDN: U101.11; also elsewhere on the board
/PINC_VOLUP: U101.6; also elsewhere on the board
/REM_RX: U101.14; also elsewhere on the board
/SEL_ADDR0: U101.23; also elsewhere on the board
/SEL_ADDR1: U101.24; also elsewhere on the board
/SEL_ADDR2: U101.25; also elsewhere on the board
/SPI_MISO: U101.18; also elsewhere on the board
/VFD_CS: U101.15; also elsewhere on the board
DGND: U101.8, U101.22; also elsewhere on the board
unnamed 70: U101.21; also elsewhere on the board

File control board/BOM 20140411155840.xlsx:

Value | Quantity | Ref
1n | 2 | C205 C210
47n | 2 | C204 C209
100n | 11 | C101 C102 C104 C105 C114 C123 C211 C212 C213 C214 C215
470n | 16 | C106 C107 C108 C109 C110 C111 C112 C113 C115 C116 C117 C118 C119 C120 C121 C122
10u | 6 | C201 C202 C203 C206 C207 C208
100u | 2 | C103 C124
EEPROM | 1 | D101
TSOP48 | 1 | J101
LINE IN | 1 | J102
ENCODERS | 1 | J103
ICSP | 1 | J104
DISPLAY | 1 | J105
CB POWER | 1 | J106
AMP INR | 1 | J107
AMP OUTL | 1 | J108
AMP OUTR | 1 | J109
HP OUT/DET | 1 | J110
LDR | 1 | J111
ICSP POWER | 1 | JP101
EC2-5NU | 1 | K101
AMP INL | 1 | P102
2N2222 | 1 | Q101
330 | 1 | R131
470 | 4 | R125 R126 R129 R130
1k | 7 | R111 R112 R113 R128 R215 R216 R217
2.2k | 2 | R205 R222
4.7k | 3 | R127 R202 R219
10k | 9 | R102 R208 R211 R212 R214 R225 R228 R229 R231
22k | 26 | R103 R104 R105 R106 R107 R108 R109 R110 R114 R115 R116 R117 R118 R119 R120 R121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
33k | 2 | R203 R220
47k | 2 | R218 R226
100k | 2 | R206 R223
SPK OUTL | 1 | SP101
SPK OUTR | 1 | SP102
TL972 | 2 | U201 U205
ATMEGA168-A | 1 | U101
MAX4617 | 2 | U102 U103
MCP42100_VOL | 1 | U202
MCP42100_TREB | 1 | U203
MCP42100_BASS | 1 | U204

## Commit log

2014-03-09 Adding files--project may not like being moved
2014-03-19 Edit amp's feedback compensation cap value
    was 150p, now 100p because of availability
2014-04-11 Fix capacitor polarity & prep for SMT
    The control board and preamp are being prepared for SMT, and the CP1
    module does not associate polarity correctly.
2014-04-11 Generate BOM
